# Keil uVision project PRO.uvprojx, settings and files
target QX (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PRO
  AfterMake: D:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o ..\BIN\MAIN.bin ..\PROJECT\Objects\PRO.axf
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\DRIVER\delay;..\DRIVER\usart;..\HARDWARE;..\MAIN;..\RTCM;..\STM32F10x_StdPeriph_Driver\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\DRIVER\sys;..\DRIVER\TIMER;..\DRIVER\AD;..\DRIVER\SPI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group DRIVER
    ../DRIVER/delay/: delay.c
    ../DRIVER/usart/: usart.c
    ../DRIVER/sys/: sys.c
    ../DRIVER/AD/: ad.c
    ../DRIVER/SPI/: spi.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/QX/: socket.c ef_qx.c
    ../HARDWARE/SIM7600/: sim7600.c
    ../HARDWARE/BLUETOOTH/: bluetooth.c
    ../HARDWARE/FM25V01/: fm25v01.c
    ../HARDWARE/KEY_POW/: key_pow.c
    ../HARDWARE/WT5883/: wt5883.c
  group MAIN
    ../MAIN/: main.c
  group RTCM
    ../RTCM/: rtcm.lib
  group STM32_LIB
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm
